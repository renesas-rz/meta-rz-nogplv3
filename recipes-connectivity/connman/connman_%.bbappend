# Avoid depend on readline, which has license GPLv3
PACKAGECONFIG:remove = "client"
