# Don't recommend tar, which has GPLv3 license
RRECOMMENDS:${PN}-container:remove = "tar"
