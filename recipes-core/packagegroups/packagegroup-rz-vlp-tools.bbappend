RDEPENDS:packagegroup-rz-vlp-tools-base:remove = "dosfstools"
