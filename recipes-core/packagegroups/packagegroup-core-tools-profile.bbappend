RRECOMMENDS:${PN}:remove = "${PERF}"
