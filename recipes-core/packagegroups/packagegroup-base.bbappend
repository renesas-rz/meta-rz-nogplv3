RRECOMMENDS:packagegroup-base-ext2:remove = "hdparm"
