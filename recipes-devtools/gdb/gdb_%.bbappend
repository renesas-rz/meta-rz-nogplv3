# Avoid depend on readline, which have license GPLv3
PACKAGECONFIG:remove = "readline"
