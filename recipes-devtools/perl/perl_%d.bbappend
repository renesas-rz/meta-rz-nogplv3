# Avoid depend on gdbm, which has license GPLv3
PACKAGECONFIG:remove = "gdbm"
