# Avoid depend on readline and gdbm, which have license GPLv3
PACKAGECONFIG:remove = "readline gdbm"
