# Don't recommend gnupg, which has GPLv3 license
RRECOMMENDS:${PN}:class-target:remove = "gnupg"
